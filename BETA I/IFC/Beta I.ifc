Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-07-20T15:39:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 20 15:39:30 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{9CEFCAE8-4242-4D66-85A0-4D6CB106615C}\ifc * Database version: 5507 * Database creation date: Tue Jul 20 15:39:29 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 20 15:39:29 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 20 15:39:29 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: BETA I_tus paravan, BETA I_tus paravan:BETA I_tus paravan:466699
In: Level 1
Type - Material: AQ_Srebrni profil, AQ_Prozirno staklo
Type - Identity Data - Boja profila: srebrna, crna; Efekt stakla: prozirnof; Izrada po mjeri: ne; Izradio: Intelika d.o.o.; Manufacturer: Aquaestil; Model: BETA I; Montaža na: kadu; Type Name: BETA I_tus paravan; Web adresa: https://www.aquaestil.hr/hr/proizvodi/paravani/56-beta-i.html
Type - Materials and Finishes - Materijal profili: AQ_Srebrni profil; Materijal staklo: AQ_Prozirno staklo
Type - Other - Category: Generic Models; Family Name: BETA I_tus paravan
Pset_BuildingElementProxyCommon - Reference: BETA I_tus paravan:BETA I_tus paravan
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.43835 m2; Visina ugradnje: 900 mm; Volume: 0.00715589 m3
Other - Family: BETA I_tus paravan: BETA I_tus paravan; Family and Type: BETA I_tus paravan: BETA I_tus paravan; Type: BETA I_tus paravan: BETA I_tus paravan; Type Id: BETA I_tus paravan: BETA I_tus paravan
Phasing - Phase Created: New Construction
